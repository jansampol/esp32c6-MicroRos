#include "InputController/DisplayCanvas.h"

#include <cstdarg>
#include <cstdio>
#include <cstring>

namespace {
struct Glyph {
    char c;
    uint8_t rows[7];
};

// 5x7 glyphs for UI text (uppercase-focused).
static const Glyph kGlyphs[] = {
    {' ', {0x00,0x00,0x00,0x00,0x00,0x00,0x00}},
    {':', {0x00,0x04,0x04,0x00,0x04,0x04,0x00}},
    {'.', {0x00,0x00,0x00,0x00,0x00,0x06,0x06}},
    {'-', {0x00,0x00,0x00,0x1F,0x00,0x00,0x00}},
    {'/', {0x01,0x02,0x04,0x08,0x10,0x00,0x00}},
    {'?', {0x0E,0x11,0x01,0x02,0x04,0x00,0x04}},
    {'&', {0x0C,0x12,0x14,0x08,0x15,0x12,0x0D}},
    {'(', {0x04,0x08,0x10,0x10,0x10,0x08,0x04}},
    {')', {0x04,0x02,0x01,0x01,0x01,0x02,0x04}},
    {'0', {0x0E,0x11,0x13,0x15,0x19,0x11,0x0E}},
    {'1', {0x04,0x0C,0x14,0x04,0x04,0x04,0x1F}},
    {'2', {0x0E,0x11,0x01,0x06,0x08,0x10,0x1F}},
    {'3', {0x1E,0x01,0x01,0x0E,0x01,0x01,0x1E}},
    {'4', {0x02,0x06,0x0A,0x12,0x1F,0x02,0x02}},
    {'5', {0x1F,0x10,0x10,0x1E,0x01,0x01,0x1E}},
    {'6', {0x06,0x08,0x10,0x1E,0x11,0x11,0x0E}},
    {'7', {0x1F,0x01,0x02,0x04,0x08,0x08,0x08}},
    {'8', {0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E}},
    {'9', {0x0E,0x11,0x11,0x0F,0x01,0x02,0x0C}},
    {'A', {0x04,0x0A,0x11,0x11,0x1F,0x11,0x11}},
    {'B', {0x1E,0x11,0x11,0x1E,0x11,0x11,0x1E}},
    {'C', {0x0E,0x11,0x10,0x10,0x10,0x11,0x0E}},
    {'D', {0x1C,0x12,0x11,0x11,0x11,0x12,0x1C}},
    {'E', {0x1F,0x10,0x10,0x1E,0x10,0x10,0x1F}},
    {'F', {0x1F,0x10,0x10,0x1E,0x10,0x10,0x10}},
    {'G', {0x0E,0x11,0x10,0x13,0x11,0x11,0x0E}},
    {'H', {0x11,0x11,0x11,0x1F,0x11,0x11,0x11}},
    {'I', {0x0E,0x04,0x04,0x04,0x04,0x04,0x0E}},
    {'J', {0x07,0x02,0x02,0x02,0x12,0x12,0x0C}},
    {'K', {0x11,0x12,0x14,0x18,0x14,0x12,0x11}},
    {'L', {0x10,0x10,0x10,0x10,0x10,0x10,0x1F}},
    {'M', {0x11,0x1B,0x15,0x15,0x11,0x11,0x11}},
    {'N', {0x11,0x19,0x15,0x13,0x11,0x11,0x11}},
    {'O', {0x0E,0x11,0x11,0x11,0x11,0x11,0x0E}},
    {'P', {0x1E,0x11,0x11,0x1E,0x10,0x10,0x10}},
    {'Q', {0x0E,0x11,0x11,0x11,0x15,0x12,0x0D}},
    {'R', {0x1E,0x11,0x11,0x1E,0x14,0x12,0x11}},
    {'S', {0x0F,0x10,0x10,0x0E,0x01,0x01,0x1E}},
    {'T', {0x1F,0x04,0x04,0x04,0x04,0x04,0x04}},
    {'U', {0x11,0x11,0x11,0x11,0x11,0x11,0x0E}},
    {'V', {0x11,0x11,0x11,0x11,0x11,0x0A,0x04}},
    {'W', {0x11,0x11,0x11,0x15,0x15,0x15,0x0A}},
    {'X', {0x11,0x11,0x0A,0x04,0x0A,0x11,0x11}},
    {'Y', {0x11,0x11,0x0A,0x04,0x04,0x04,0x04}},
    {'Z', {0x1F,0x01,0x02,0x04,0x08,0x10,0x1F}},
};
}

DisplayCanvas::DisplayCanvas(int width, int height, uint16_t* buffer)
    : _width(width), _height(height), _buffer(buffer)
{
}

void DisplayCanvas::fillScreen(uint16_t color)
{
    if (_buffer == nullptr) return;
    const size_t pixels = static_cast<size_t>(_width) * _height;
    for (size_t i = 0; i < pixels; ++i) {
        _buffer[i] = color;
    }
}

void DisplayCanvas::fillRect(int x, int y, int w, int h, uint16_t color)
{
    if (_buffer == nullptr || w <= 0 || h <= 0) return;
    const int x0 = (x < 0) ? 0 : x;
    const int y0 = (y < 0) ? 0 : y;
    const int x1 = ((x + w) > _width) ? _width : (x + w);
    const int y1 = ((y + h) > _height) ? _height : (y + h);
    for (int yy = y0; yy < y1; ++yy) {
        for (int xx = x0; xx < x1; ++xx) {
            _buffer[yy * _width + xx] = color;
        }
    }
}

void DisplayCanvas::setTextColor(uint16_t color) { _textColor = color; }
void DisplayCanvas::setTextSize(uint8_t size) { _textSize = (size == 0) ? 1 : size; }
void DisplayCanvas::setCursor(int x, int y) { _cursorX = x; _cursorY = y; }

void DisplayCanvas::print(const char* text)
{
    if (text == nullptr) return;
    while (*text != '\0') {
        print(*text++);
    }
}

void DisplayCanvas::print(const std::string& text) { print(text.c_str()); }

void DisplayCanvas::print(char c)
{
    if (c == '\n') {
        _cursorX = 0;
        _cursorY += static_cast<int>(8 * _textSize);
        return;
    }
    drawChar(_cursorX, _cursorY, c, _textColor, _textSize);
    _cursorX += static_cast<int>(6 * _textSize);
}

void DisplayCanvas::print(int value)
{
    char buf[24];
    std::snprintf(buf, sizeof(buf), "%d", value);
    print(buf);
}

void DisplayCanvas::print(unsigned value)
{
    char buf[24];
    std::snprintf(buf, sizeof(buf), "%u", value);
    print(buf);
}

void DisplayCanvas::print(float value, int decimals)
{
    if (decimals < 0) decimals = 0;
    if (decimals > 6) decimals = 6;
    char fmt[12];
    char buf[32];
    std::snprintf(fmt, sizeof(fmt), "%%.%df", decimals);
    std::snprintf(buf, sizeof(buf), fmt, static_cast<double>(value));
    print(buf);
}

void DisplayCanvas::printf(const char* fmt, ...)
{
    if (fmt == nullptr) return;
    char buf[128];
    va_list args;
    va_start(args, fmt);
    std::vsnprintf(buf, sizeof(buf), fmt, args);
    va_end(args);
    print(buf);
}

void DisplayCanvas::drawPixel(int x, int y, uint16_t color)
{
    if (_buffer == nullptr) return;
    if (x < 0 || y < 0 || x >= _width || y >= _height) return;
    _buffer[y * _width + x] = color;
}

const uint8_t* DisplayCanvas::glyphFor(char c) const
{
    if (c >= 'a' && c <= 'z') {
        c = static_cast<char>(c - 'a' + 'A');
    }
    for (const auto& g : kGlyphs) {
        if (g.c == c) {
            return g.rows;
        }
    }
    for (const auto& g : kGlyphs) {
        if (g.c == '?') return g.rows;
    }
    return kGlyphs[0].rows; // space
}

void DisplayCanvas::drawChar(int x, int y, char c, uint16_t color, uint8_t size)
{
    const uint8_t* rows = glyphFor(c);
    for (int row = 0; row < 7; ++row) {
        for (int col = 0; col < 5; ++col) {
            if ((rows[row] >> (4 - col)) & 0x01) {
                if (size == 1) {
                    drawPixel(x + col, y + row, color);
                } else {
                    fillRect(x + col * size, y + row * size, size, size, color);
                }
            }
        }
    }
}
